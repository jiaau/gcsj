# Keil uVision project gcsj.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: -AT32F407VGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1
  c include: .\include\core;.\include\device;.\include\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ./user/: main.c
  group device
    ./device/: at32f403a_407_board.c at32f403a_407_clock.c at32f403a_407_int.c system_at32f403a_407.c
  group drivers
    ./drivers/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group core
    ./core/: startup_at32f403a_407.s
